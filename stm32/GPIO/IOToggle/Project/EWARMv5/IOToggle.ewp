# IAR project IOToggle.ewp, settings and files
configuration IOToggle_Flash (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: ..\..\User\inc; ..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: IOToggle.srec
  ILINK.IlinkOutputFile: IOToggle.out
  ILINK.IlinkIcfFile: E:\codes\Stm32\BasicLearning\GPIO\IOToggle\Project\EWARMv5\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration IOToggle_CpuRam (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: stm32f10x_ram.icf
configuration IOToggle_ExtSram (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: stm32f10x_extsram.icf
  group CMSIS
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../User/src/: system_stm32f10x.c
  group EWARM
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
  group Libraries
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c
  group User
    ../../User/src/: main.c stm32f10x_it.c
