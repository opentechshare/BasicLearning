# Keil uVision project IOToggle.uvproj, settings and files
target IOToggle_Flash (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: IOToggle +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\User\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group RVMDK
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../User/src/: system_stm32f10x.c
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c
  group User
    ../../User/src/: main.c stm32f10x_it.c
target IOToggle_CpuRam (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: as above
  output: IOToggle +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=870
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x8000
  memory RVCT9: RAM 0x20008000 size 0x8000
target IOToggle_ExtSram (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: as above
  output: IOToggle +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,VECT_TAB_SRAM
  c misc: --diag_suppress=870
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x68000000 size 0x80000
  memory RVCT9: RAM 0x68080000 size 0x80000
